# IAR project STM_ble_app.ewp, settings and files
configuration STM_ble_app (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xE ST STM32L152xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_XL; SVCALL_AS_NORMAL_FUNCTION
  ICCARM.CCDiagSuppress: Pe301
  ICCARM.CCIncludePath2: ..\..\..\Libraries\STMxx_nRF51_Driver\Lib\ble\inc; ..\..\..\Libraries\STMxx_nRF51_Driver\Custom_Services\inc; ..\..\..\Libraries\STMxx_nRF51_Driver\Lib\Services\inc; ..\..\..\Libraries\STMxx_nRF51_Driver\Lib\Codecs\inc; ..\..\..\Libraries\STMxx_nRF51_Driver\Interfaces\inc; ..\..\..\Libraries\STM32L1xx_NVM_Driver\inc; ..\..\..\Libraries\STM32L1xx_TimerServer\inc; ..\..\..\Libraries\STM32L1xx_LowPowerManager\inc; ..\..\..\Libraries\STM32L1xx_LowPowerUART_Driver\inc; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\Common; ..\..\..\Utilities\STM32_Nucleo\adafruit; ..\..\..\Utilities\ThirdParty\FatFS\src; ..\..\..\Utilities\Wavetek\stm32l1xx; ..\..\..\Utilities\STM32_Nucleo\stm32l1xx; ..\..\STM_ble_app; ..\..\..\Libraries\CMSIS_Core\Include; ..\..\..\Libraries\CMSIS_Device_STM32L1xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM_ble_app.hex
  ILINK.IlinkOutputFile: STM_ble_app.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ble
    ../../../Libraries/STMxx_nRF51_Driver/Lib/ble/src/: ble.c ble_advdata.c ble_bondmngr.c ble_conn_params.c ble_encode_transport.c ble_gap.c ble_gattc.c ble_gatts.c ble_l2cap.c crc16.c nrf_soc.c raw_transport.c
  group ble_codecs
    ../../../Libraries/STMxx_nRF51_Driver/Lib/Codecs/src/: ble_enable.c ble_event.c ble_evt_tx_complete.c ble_gap_address_get.c ble_gap_address_set.c ble_gap_adv_data_set.c ble_gap_adv_start.c ble_gap_adv_stop.c ble_gap_appearance_get.c ble_gap_appearance_set.c ble_gap_auth_key_reply.c ble_gap_authenticate.c ble_gap_conn_param_update.c ble_gap_conn_sec_get.c ble_gap_device_name_get.c ble_gap_device_name_set.c ble_gap_disconnect.c ble_gap_evt_auth_key_request.c ble_gap_evt_auth_status.c ble_gap_evt_conn_param_update.c ble_gap_evt_conn_sec_update.c ble_gap_evt_connected.c ble_gap_evt_disconnected.c ble_gap_evt_passkey_display.c ble_gap_evt_rssi_changed.c ble_gap_evt_sec_info_request.c ble_gap_evt_sec_params_request.c ble_gap_evt_timeout.c ble_gap_ppcp_get.c ble_gap_ppcp_set.c ble_gap_rssi_start.c ble_gap_rssi_stop.c ble_gap_sec_info_reply.c ble_gap_sec_params_reply.c ble_gap_struct_serialization.c ble_gap_tx_power_set.c ble_gattc_char_value_by_uuid_read.c ble_gattc_char_values_read.c ble_gattc_characteristics_discover.c ble_gattc_descriptors_discover.c ble_gattc_evt_char_disc_rsp.c ble_gattc_evt_char_val_by_uuid_read_rsp.c ble_gattc_evt_char_vals_read_rsp.c ble_gattc_evt_desc_disc_rsp.c ble_gattc_evt_hvx.c ble_gattc_evt_prim_srvc_disc_rsp.c ble_gattc_evt_read_rsp.c ble_gattc_evt_rel_disc_rsp.c ble_gattc_evt_timeout.c ble_gattc_evt_write_rsp.c ble_gattc_hv_confirm.c ble_gattc_primary_services_discover.c ble_gattc_read.c ble_gattc_relationships_discover.c ble_gattc_struct_serialization.c ble_gattc_write.c ble_gatts_characteristic_add.c ble_gatts_descriptor_add.c ble_gatts_evt_hvc.c ble_gatts_evt_rw_authorize_request.c ble_gatts_evt_sc_confirm.c ble_gatts_evt_sys_attr_missing.c ble_gatts_evt_timeout.c ble_gatts_evt_write.c ble_gatts_hvx.c ble_gatts_include_add.c ble_gatts_rw_authorize_reply.c ble_gatts_service_add.c ble_gatts_service_changed.c ble_gatts_struct_serialization.c ble_gatts_sys_attr_get.c ble_gatts_sys_attr_set.c ble_gatts_value_get.c ble_gatts_value_set.c ble_l2cap_cid_register.c ble_l2cap_cid_unregister.c ble_l2cap_evt_rx.c ble_l2cap_tx.c ble_opt_get.c ble_opt_set.c ble_serialization.c ble_struct_serialization.c ble_tx_buffer_count_get.c ble_uuid_decode.c ble_uuid_encode.c ble_uuid_vs_add.c ble_version_get.c cond_field_serialization.c power_system_off.c temp_get.c
  group ble_interfaces
    ../../../Libraries/STMxx_nRF51_Driver/Interfaces/src/: ble_nvm.c ble_timer.c ble_uart.c blocking.c
  group ble_services
    ../../../Libraries/STMxx_nRF51_Driver/Lib/Services/src/: ble_bas.c ble_dis.c ble_hrs.c ble_hts.c ble_srv_common.c
  group CMSIS_Device_STM32L1xx
    ../../../Libraries/CMSIS_Device_STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_xl.s
  group Custom_services
    ../../../Libraries/STMxx_nRF51_Driver/Custom_Services/src/: ble_ledbutton.c
  group STM32L1xx_LowPowerManager
    ../../../Libraries/STM32L1xx_LowPowerManager/src/: stm32l1xx_lpm.c
  group STM32L1xx_LowPowerUART_Driver
    ../../../Libraries/STM32L1xx_LowPowerUART_Driver/src/: hal_uart.c
  group STM32L1xx_NVM_Driver
    ../../../Libraries/STM32L1xx_NVM_Driver/src/: hal_nvm.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group STM32L1xx_TimerServer
    ../../../Libraries/STM32L1xx_TimerServer/src/: hal_timer.c
  group User
    ../: app_stm32_adafruit_spi_lcd.c ble_app_main.c ble_sensorsim.c fatfs_drv.c fatfs_storage.c main.c stm32l1xx_it.c system_stm32l1xx.c
  group Utilities
    ../../../Utilities/ThirdParty/FatFS/src/: ff.c
    ../../../Utilities/Common/: fonts.c
    ../../../Utilities/STM32_Nucleo/adafruit/: stm32_adafruit_spi_usd.c
    ../../../Utilities/STM32_Nucleo/stm32l1xx/: stm32l1xx_nucleo.c
    ../../../Utilities/Wavetek/stm32l1xx/: stm32l1xx_wavetek.c
