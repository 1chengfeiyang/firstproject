<?xml version="1.0" encoding="iso-8859-1" standalone="no" ?><workspace>
  <project>
    <path>$WS_DIR$\STM_ble_app.ewp</path>
  </project>
  <batchBuild/>
</workspace>